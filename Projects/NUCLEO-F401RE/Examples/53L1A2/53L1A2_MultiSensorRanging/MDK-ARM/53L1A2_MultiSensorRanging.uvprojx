# Keil uVision project 53L1A2_MultiSensorRanging.uvprojx, settings and files
target 53L1A2_MultiSensorRanging (5060960::V5.06 update 7 (build 960)::.\ARMCC\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 53L1A2_MultiSensorRanging +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xE
  c include: ../Inc;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/vl53l1cb/modules;../../../../../../Drivers/BSP/Components/vl53l1cb/porting;../../../../../../Drivers/BSP/Components/vl53l1cb;../../../../../../Drivers/BSP/53L1A2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: main.c app_tof.c stm32f4xx_nucleo_bus.c stm32f4xx_nucleo.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/vl53l1cb/modules/: vl53l1_api.c vl53l1_api_calibration.c vl53l1_api_core.c vl53l1_api_debug.c vl53l1_api_preset_modes.c vl53l1_api_strings.c vl53l1_core.c vl53l1_core_support.c vl53l1_dmax.c vl53l1_error_strings.c vl53l1_hist_algos_gen3.c vl53l1_hist_algos_gen4.c vl53l1_hist_char.c vl53l1_hist_core.c vl53l1_hist_funcs.c vl53l1_nvm.c vl53l1_nvm_debug.c vl53l1_register_funcs.c vl53l1_sigma_estimate.c vl53l1_silicon_core.c vl53l1_wait.c vl53l1_xtalk.c vl53l1_zone_presets.c
    ../../../../../../Drivers/BSP/Components/vl53l1cb/porting/: vl53l1_platform.c vl53l1_platform_ipp.c vl53l1_platform_log.c
    ../../../../../../Drivers/BSP/Components/vl53l1cb/: vl53l1cb.c
  group Drivers/BSP/53L1A2
    ../../../../../../Drivers/BSP/53L1A2/: 53l1a2.c 53l1a2_ranging_sensor.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/X-CUBE-TOF1/Documentation
    ../../../../../../Drivers/BSP/Components/vl53l1cb/: LICENSE.txt
    ../../../../../../Drivers/BSP/Components/vl53l1cb/modules/: ReleaseNotes.txt
    ../../../../../../Drivers/BSP/53L1A2/: LICENSE.txt
software components: CMSIS:CORE 5.6.0
